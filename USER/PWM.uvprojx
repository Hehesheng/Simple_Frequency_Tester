# Keil uVision project PWM.uvprojx, settings and files
target PWM (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\ADC;..\FWLIB\src;..\HARDWARE\GPIO;..\HARDWARE\ads1115;..\HARDWARE\IIC;..\HARDWARE\AD9959;..\SYSTEM\tasks
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/ads1115/: ads1115.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/AD9959/: AD9959.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tasks/: task.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_adc.c
  group README
    ../: readme.txt
